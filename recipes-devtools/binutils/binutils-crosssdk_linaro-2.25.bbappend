
SRC_URI = "https://releases.linaro.org/archive/${MMYY}/components/toolchain/binutils-linaro/binutils-linaro-${BPV}-${RELEASE}.tar.xz"
