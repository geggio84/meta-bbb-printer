
SRC_URI = "git://github.com/omapconf/omapconf.git;protocol=https;branch=${BRANCH}"

