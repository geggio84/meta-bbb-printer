FILESEXTRAPATHS_prepend := "${THISDIR}/gcc-source-4.9:"

SRC_URI += "file://0060-gcc-var-tracking.c-backport-from-gcc-trunk-r212178.patch \
           "
