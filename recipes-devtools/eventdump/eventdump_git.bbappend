
SRC_URI = "git://github.com/TI-ECS/eventdump.git;protocol=https"

