
SRC_URI = "https://github.com/webmproject/libwebp/archive/refs/tags/v${PV}.zip"

SRC_URI[md5sum] = "c8dd1d26eb9566833aba269b86d97e68"
SRC_URI[sha256sum] = "31913577e96386556855b41d210736449445fe96cfbe9289014e9b8afa944d69"

