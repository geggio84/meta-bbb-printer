SRC_URI = "https://github.com/libav/libav/archive/refs/tags/v${PV}.zip"

SRC_URI[md5sum] = "74cb8240d9cf8e4b0dab5cb80e97e304"
SRC_URI[sha256sum] = "1c492b9d3b4a9c6682e735bb57fcc3abebc588fca161d771fec8133fe351f234"
