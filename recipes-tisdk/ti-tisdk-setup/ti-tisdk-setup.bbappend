
SRC_URI = "git://git.ti.com/arago-project/tisdk-setup-scripts.git;protocol=git;branch=${BRANCH}"

